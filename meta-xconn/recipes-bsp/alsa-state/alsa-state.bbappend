FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

PR:append = ".xc1"
