# XC ships all matching modules in xc-hardware, without OE split packages.
RRECOMMENDS:packagegroup-base:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-base-3g:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-base-alsa:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-base-bluetooth:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-base-cramfs:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-base-ext2:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-base-ipsec:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-base-ipv6:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-base-nfc:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-base-nfs:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-base-pcmcia:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-base-ppp:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-base-smbfs:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-base-usbgadget:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-base-usbhost:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-base-vfat:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-base-wifi:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-distro-base:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
RRECOMMENDS:packagegroup-machine-base:remove = "kernel-module-aes kernel-module-aes-generic kernel-module-airo-cs kernel-module-arc4 kernel-module-bluecard-cs kernel-module-bluetooth kernel-module-bluetooth3c-cs kernel-module-bluetoothuart-cs kernel-module-bnep kernel-module-cdc-acm kernel-module-cdc-wdm kernel-module-cifs kernel-module-cramfs kernel-module-crypto_algapi kernel-module-cryptomgr kernel-module-dtl1-cs kernel-module-ecb kernel-module-ehci-hcd kernel-module-g-ether kernel-module-g-file-storage kernel-module-g-serial kernel-module-gadgetfs kernel-module-hci-uart kernel-module-hci-usb kernel-module-hci-vhci kernel-module-hidp kernel-module-hostap-cs kernel-module-ide-cs kernel-module-ide-disk kernel-module-ieee80211-crypt kernel-module-ieee80211-crypt-ccmp kernel-module-ieee80211-crypt-tkip kernel-module-ieee80211-crypt-wep kernel-module-input kernel-module-ipsec kernel-module-ipv6 kernel-module-l2cap kernel-module-michael-mic kernel-module-mousedev kernel-module-msdos kernel-module-nfc kernel-module-nfs kernel-module-nls-cp437 kernel-module-nls-iso8859-1 kernel-module-nls-utf8 kernel-module-ohci-hcd kernel-module-orinoco-cs kernel-module-pcmcia kernel-module-pcnet-cs kernel-module-ppp-async kernel-module-ppp-deflate kernel-module-ppp-generic kernel-module-ppp-mppe kernel-module-pxa27x_udc kernel-module-rfcomm kernel-module-rtc-dev kernel-module-rtc-proc kernel-module-rtc-sysfs kernel-module-sco kernel-module-scsi-mod kernel-module-sd-mod kernel-module-serial-cs kernel-module-slhc kernel-module-smbfs kernel-module-snd-mixer-oss kernel-module-snd-pcm-oss kernel-module-spectrum-cs kernel-module-uhci-hcd kernel-module-uinput kernel-module-unix kernel-module-usb-storage kernel-module-usbcore kernel-module-usbhid kernel-module-usbmouse kernel-module-usbnet kernel-module-usbserial kernel-module-vfat kernel-module-zd1211rw"
