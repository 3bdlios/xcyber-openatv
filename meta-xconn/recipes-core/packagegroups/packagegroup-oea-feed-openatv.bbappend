# cdfs is an external kernel module without a matching XC kernel build recipe.
RRECOMMENDS:${PN}:remove = "cdfs"
