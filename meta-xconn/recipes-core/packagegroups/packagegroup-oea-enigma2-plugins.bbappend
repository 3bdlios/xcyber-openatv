# USB serial adapter modules are not part of the XC hardware bundle.
PLUGINS_CORE_EXTENDED:remove = "enigma2-plugin-drivers-usbserial"
